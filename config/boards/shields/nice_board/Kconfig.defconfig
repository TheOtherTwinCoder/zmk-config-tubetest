## config/boards/shields/nice_board/Kconfig.defconfig
```kconfig
if SHIELD_TWO_PERCENT_MILK

config ZMK_KEYBOARD_NAME
    default "NiceBoard"

endif
```
